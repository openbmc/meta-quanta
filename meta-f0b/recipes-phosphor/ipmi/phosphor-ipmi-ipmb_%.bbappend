FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-modify-ipmbChannel-type-and-included-library.patch"
